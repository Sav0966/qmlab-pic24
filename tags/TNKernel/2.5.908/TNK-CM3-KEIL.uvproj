# Keil uVision project TNK-CM3-KEIL.uvproj, settings and files
target SIM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: TNK-CM3-KEIL
  c flags: Optim=1
  c include: .\source\example\example_1\bsp;.\source\example\example_1;.\source\example\example_1\bsp\lpc17xx;.\source\tnkernel
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Application
    ./source/example/example_1/: main.c
    ./source/example/example_1/bsp/lpc17xx/: lpc17xx_core.c startup_keil_cm3.s startup_keil_cm3_hw_init.s bsp.c
  group TNKernel
    ./source/tnkernel/_lib/: tnkernel_cm3_rv.a
target JLINK (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: TNK-CM3-KEIL
  c flags: Optim=4 OneElfS=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
